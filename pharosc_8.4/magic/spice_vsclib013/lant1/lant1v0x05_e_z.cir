* e_z transition of lant1v0x05, 0.13um, Berkeley generic bsim3 params
* lant1v0x05_e_z.cir 2007-07-09:20h07 graham
* FLOW
* instantiate one subckt for each load cap to be measured
* for each input to output transition (two, LH and HL)
*   for each input transition (10 here)
*     measure time where Vin crosses VDD*input_threshold (tP)
*     for each subckt with its different load
*       meaasure time between tP and where Vout crosses VDD*output_threshold
*       measure the output slope between VDD*slope_lo and VDD*slope_h and scale to full swing value
*     measure input current for each input transition and convert to capacitance
*     calculate Prop Ramp delays for each input transition from x1, x2 and x3 (normal load cap values)
*     average the power caused by the 2 transitions for each subckt (except one with largest load)
*         and subtract the load power
*   average input pin capacitance over transitions 90ps to 450ps (likeliest transitions)
*   write Prop-Ramp info in VBE file format for Alliance tools
*   write table of delays for each of the 6 load caps and 10 transitions (6x10 LUT)
*   write table of transition times for each of the 6 load caps and 10 transitions (6x10 LUT)
* write power LUT for each of 5 load caps and 10 transitions (5x10 LUT)
*
* timing_sense output_file       d    z
*     -1            1      0_lh low  high   not possible
*     -1            2      0_hh low   \     same as df
*      1            1      1_hl high  /     same as df
*      1            2      1_ll high low    not possible
*      0            1      0_ll low  low    same as df
*      0            2      0_hl low  low    same as df
*      0            3      1_hh high high   same as df
*      0            4      1_lh high high   same as df
*
.include ../../../magic/subckt/vsclib013/spice_model.lib
.include ../../../magic/subckt/vsclib013/lant1v0x05.spi
.include ../../../magic/subckt/vsclib013/params.inc
*
x0  d_0  e_0  vdd0 vss0  x0z  lant1v0x05
x1  d_1  e_1  vdd1 vss1  x1z  lant1v0x05
x2  d_2  e_2  vdd2 vss2  x2z  lant1v0x05
x3  d_3  e_3  vdd3 vss3  x3z  lant1v0x05
x4  d_4  e_4  vdd4 vss4  x4z  lant1v0x05
x5  d_5  e_5  vdd5 vss5  x5z  lant1v0x05
*
cx0z  x0z  0 0
cx1z  x1z  0 0
cx2z  x2z  0 0
cx3z  x3z  0 0
cx4z  x4z  0 0
cx5z  x5z  0 0
*
vdd0 vdd0 0 'vdd'
vdd1 vdd1 0 'vdd'
vdd2 vdd2 0 'vdd'
vdd3 vdd3 0 'vdd'
vdd4 vdd4 0 'vdd'
vdd5 vdd5 0 'vdd'
vss0 0 vss0 'vss'
vss1 0 vss1 'vss'
vss2 0 vss2 'vss'
vss3 0 vss3 'vss'
vss4 0 vss4 'vss'
vss5 0 vss5 'vss'
*
Vref ref 0 dc 0 pwl(0 0 100p 0 200p 0 )
cref ref 0 100f
Vstrobe strobe 0 dc 0 pulse (0 1 1000p 0 0 5000p)
Vd_0 d_0 0 dc 0 pwl(0 0 100p 0 200p 0 )
Vd_1 d_1 0 dc 0 pwl(0 0 100p 0 200p 0 )
Vd_2 d_2 0 dc 0 pwl(0 0 100p 0 200p 0 )
Vd_3 d_3 0 dc 0 pwl(0 0 100p 0 200p 0 )
Vd_4 d_4 0 dc 0 pwl(0 0 100p 0 200p 0 )
Vd_5 d_5 0 dc 0 pwl(0 0 100p 0 200p 0 )
Ve_0 e_0 0 dc 0 pwl(0 0 100p 0 200p 0 )
Ve_1 e_1 0 dc 0 pwl(0 0 100p 0 200p 0 )
Ve_2 e_2 0 dc 0 pwl(0 0 100p 0 200p 0 )
Ve_3 e_3 0 dc 0 pwl(0 0 100p 0 200p 0 )
Ve_4 e_4 0 dc 0 pwl(0 0 100p 0 200p 0 )
Ve_5 e_5 0 dc 0 pwl(0 0 100p 0 200p 0 )
*

.control
  set width=136 height=500 numdgt=3 noprintscale nobreak noaskquit=1

  set unitcap=1.75f
  set loadcap0=1
  set loadcap1=4
  set loadcap2=12
  set loadcap3=30
  set loadcap4=62
  set loadcap5=130
  set drive_strength = 0.5
  set input_threshold_rise = 0.5
  set input_threshold_fall = 0.5
  set output_threshold_rise = 0.5
  set output_threshold_fall = 0.5
  set lower_lh = 0.100
  set upper_lh = 0.900
  set lower_hl = 0.100
  set upper_hl = 0.900
  set lower_hh = 0.100
  set upper_hh = 0.900
  set lower_ll = 0.100
  set upper_ll = 0.900

  foreach n 0 1 2 3 4 5 6 7 8 9
    let pvdd0[ $n ] = 0
    let pvdd1[ $n ] = 0
    let pvdd2[ $n ] = 0
    let pvdd3[ $n ] = 0
    let pvdd4[ $n ] = 0
  end
  alter cx0z = $loadcap0 *$unitcap *$drive_strength
  alter cx1z = $loadcap1 *$unitcap *$drive_strength
  alter cx2z = $loadcap2 *$unitcap *$drive_strength
  alter cx3z = $loadcap3 *$unitcap *$drive_strength
  alter cx4z = $loadcap4 *$unitcap *$drive_strength
  alter cx5z = $loadcap5 *$unitcap *$drive_strength
  let sumx =  @cx1z[capacitance] + @cx2z[capacitance] + @cx3z[capacitance] + @cx4z[capacitance]
  let sumx2 = @cx1z[capacitance]^2 + @cx2z[capacitance]^2 + @cx3z[capacitance]^2 + @cx4z[capacitance]^2
  let in_cap = 0
  let ave_cap[1] = 0
  let tPlh_z = 0
  let tPhl_z = 0
  let tPhh_z = 0
  let tPll_z = 0
  let rup_z = 0
  let rdown_z = 0
  let simulation_no = 0
  let pwr_simulation_no = 0
  foreach timing_sense -1 1 0
    if $timing_sense=-1
      set power_type=n
    end
    if $timing_sense=1
      set power_type=p
    end
    if $timing_sense=0
      set power_type=u
    end
    foreach output_file 1 2 3 4
      if $timing_sense lt 0 and $output_file ne 2
        goto ofile
      end
      if $timing_sense gt 0 and $output_file ne 1
        goto ofile
      end
      set power_only = 1
      if $timing_sense lt 0 and $output_file = 2
        set power_only = 0
      end
      if $timing_sense gt 0 and $output_file = 1
        set power_only = 0
      end
      let num_pin_states = 0
      if $timing_sense < 0
        let pin_state[0]=0
        let pin_state[1]=-1
        let pin_state[2]=-1
        let pin_state[3]=-1
        let pin_state[4]=-1
        let pin_state[5]=-1
        let pin_state[6]=-1
        let pin_state[7]=-1
        if ( pin_state[ 0 ] = -1 )
          echo "# ? Cell has timing_sense negative_unate but other pin states have not been set."
        end
      end
      if $timing_sense > 0
        let pin_state[0]=1
        let pin_state[1]=-1
        let pin_state[2]=-1
        let pin_state[3]=-1
        let pin_state[4]=-1
        let pin_state[5]=-1
        let pin_state[6]=-1
        let pin_state[7]=-1
        if ( pin_state[ 0 ] = -1 )
          echo "# ? Cell has timing_sense positive_unate but other pin states have not been set."
        end
      end
      if $timing_sense = 0 and $output_file <= 2
        let pin_state[0]=0
        let pin_state[1]=-1
        let pin_state[2]=-1
        let pin_state[3]=-1
        let pin_state[4]=-1
        let pin_state[5]=-1
        let pin_state[6]=-1
        let pin_state[7]=-1
        if ( pin_state[ 0 ] = -1 )
          echo "# ? Cell has pin_power condition, but other pin states have not been set."
        end
      end
      if $timing_sense = 0 and $output_file > 2
        let pin_state[0]=1
        let pin_state[1]=-1
        let pin_state[2]=-1
        let pin_state[3]=-1
        let pin_state[4]=-1
        let pin_state[5]=-1
        let pin_state[6]=-1
        let pin_state[7]=-1
        if ( pin_state[ 0 ] = -1 )
          echo "# ? Cell has pin_power condition, but other pin states have not been set."
        end
      end
      let pin_state_index = 0
      while pin_state_index <= 7
        if ( pin_state[ pin_state_index ] = 0 )
          set other_pin_state=0
        else
          if ( pin_state[ pin_state_index ] = 1 )
            set other_pin_state=1
          end
        end
        if ( pin_state[ pin_state_index ] < 0 )
          set other_pin_state=-1
        else
          if $timing_sense = 0
            let pwr_simulation_no = pwr_simulation_no + 1
          else
            let simulation_no = simulation_no + 1
          end
          let num_pin_states = num_pin_states + 1
          let tPROP[0] = 0
          let tRAMP[0] = 0
          let step[0] = 0
          let prop_z[1] = 0
          let ramp_z[1] = 0
          if $output_file = 1 or $output_file = 4
            set outfall = -1
            set outhresh=$output_threshold_rise
            if $timing_sense <= 0
              set slope1 = $lower_lh
              set slope2 = $upper_lh
              set infall = 1
              set e_v1 = $vdd
              set e_v2 = $vss
              set inthresh = $input_threshold_fall
              set unate = LH
            else
              if $timing_sense > 0
                set slope1 = $lower_hh
                set slope2 = $upper_hh
                set infall = -1
                set e_v1 = $vss
                set e_v2 = $vdd
                set inthresh = $input_threshold_rise
                set unate = HH
              else
                echo "# Timing sense must be positive_unate, negative_unate or pin_power and isn't. Try again."
                break
              end
            end
          end *$output_file = 1
          if $output_file = 2 or $output_file = 3
            set outfall = 1
            set outhresh=$output_threshold_fall
            if $timing_sense <= 0
              set slope1 = $upper_hl
              set slope2 = $lower_hl
              set infall = -1
              set e_v1 = $vss
              set e_v2 = $vdd
              set inthresh = $input_threshold_rise
              set unate = HL
            else
              if $timing_sense > 0
                set slope1 = $upper_ll
                set slope2 = $lower_ll
                set infall = 1
                set e_v1 = $vdd
                set e_v2 = $vss
                set inthresh = $input_threshold_fall
                set unate = LL
              else
                echo "# Timing sense must be positive_unate, negative_unate or pin_power and isn't. Try again."
                break
              end
            end
          end *$output_file = 2
          if pin_state[ pin_state_index ] = 0
            if $timing_sense = 0
              set d_v1 = $vss
            else
              set d_v1 = $vdd
            end
            set d_v2 = $vss
          else
            if pin_state[ pin_state_index ] = 1
              if $timing_sense = 0
                set d_v1 = $vdd
              else
                set d_v1 = $vss
              end
              set d_v2 = $vdd
            end
          end
          let n = 0
          if $timing_sense = 1 and $output_file = 1
            echo "# d=H e=_/ z=_/"
          end
          if $timing_sense = -1 and $output_file = 2
            echo "# d=L e=_/ z=\_"
          end
          if $timing_sense = 0 and $output_file = 1
            echo "# d=L e=\_ z=L"
          end
          if $timing_sense = 0 and $output_file = 2
            echo "# d=L e=_/ z=L"
          end
          if $timing_sense = 0 and $output_file = 3
            echo "# d=H e=_/ z=H"
          end
          if $timing_sense = 0 and $output_file = 4
            echo "# d=H e=\_ z=H"
          end
          foreach transition 1020p 1060p 1090p 1130p 1200p 1300p 1450p 1670p 2000p 2500p
            let intran[n] = $transition - 1000p
            alter @Vref[pwl] =[ 0 $vdd 1000p $vdd $transition $vss ]
            alter @Ve_0[pwl] =[ 0 $vdd 1p $e_v1 1000p $e_v1 $transition $e_v2 ]
            alter @Ve_1[pwl] =[ 0 $vdd 1p $e_v1 1000p $e_v1 $transition $e_v2 ]
            alter @Ve_2[pwl] =[ 0 $vdd 1p $e_v1 1000p $e_v1 $transition $e_v2 ]
            alter @Ve_3[pwl] =[ 0 $vdd 1p $e_v1 1000p $e_v1 $transition $e_v2 ]
            alter @Ve_4[pwl] =[ 0 $vdd 1p $e_v1 1000p $e_v1 $transition $e_v2 ]
            alter @Ve_5[pwl] =[ 0 $vdd 1p $e_v1 1000p $e_v1 $transition $e_v2 ]
            alter @Vd_0[pwl] =[ 0 $d_v1 400p $d_v1 600p $d_v2 ]
            alter @Vd_1[pwl] =[ 0 $d_v1 400p $d_v1 600p $d_v2 ]
            alter @Vd_2[pwl] =[ 0 $d_v1 400p $d_v1 600p $d_v2 ]
            alter @Vd_3[pwl] =[ 0 $d_v1 400p $d_v1 600p $d_v2 ]
            alter @Vd_4[pwl] =[ 0 $d_v1 400p $d_v1 600p $d_v2 ]
            alter @Vd_5[pwl] =[ 0 $d_v1 400p $d_v1 600p $d_v2 ]
            if $power_only = 1
              set tstop = 3000p
            else
              set tstop = 4000p
            end
            tran $tstep $tstop
            linearize
            let tint = length(time)-1
            let simtime = time[tint]
*            plot v(e_0) v(d_0) v(x0z) v(x1z) v(x2z) v(x3z) v(x4z) v(x5z)
*            if $transition = 1200p
*              plot v(e_3) v(x3:en)
*              plot v(e_3) v(d_3) v(x3:n1) v(x3:n2) v(x3:n3) v(x3z)
*            end
            if $power_only = 0
              let simpoints = length(time)-1
*
*             set tP, the point where the input waveform crosses its threshold
*
              if $infall = 1
                let tP = ( 1 - $inthresh ) * ( $transition -1000p) + 1000p
              else
                let tP = $inthresh * ( $transition -1000p) + 1000p
              end
*
*             measure delay from tP to the nets x0z-x5z
*
              let next_est = 0
              let j = 0
              while j <= 5
                let m = simpoints/2
                let int_m = length ( vector ( m ))
                let k = 2
                repeat 16
                  let k = k * 2
                  if j=0
                    let lower_v = x0z[int_m-1]
                    let upper_v = x0z[int_m]
                  end
                  if j=1
                    let lower_v = x1z[int_m-1]
                    let upper_v = x1z[int_m]
                  end
                  if j=2
                    let lower_v = x2z[int_m-1]
                    let upper_v = x2z[int_m]
                  end
                  if j=3
                    let lower_v = x3z[int_m-1]
                    let upper_v = x3z[int_m]
                  end
                  if j=4
                    let lower_v = x4z[int_m-1]
                    let upper_v = x4z[int_m]
                  end
                  if j=5
                    let lower_v = x5z[int_m-1]
                    let upper_v = x5z[int_m]
                  end

                  if $outfall * ( upper_v - $vdd*$outhresh ) <= 0
                    if $outfall * ( lower_v - $vdd*$outhresh ) >= 0
                      goto found_m
                    else
                      let m = m - simpoints / k
                      let int_m = length ( vector ( m )) + 1
                    end
                  else
                    let m = m + simpoints / k
                    let int_m = length ( vector ( m )) + 1
                    if m >= simpoints
                      goto notfound_m
                    end
                  end
                end *repeat 16
                label notfound_m
                if j = 0
                  echo #Error: Failed to find output threshold ... setting m=simpoints/2 at unate = $unate transition = $transition, loadcap = $loadcap0
                  echo #Error: Failed to find output threshold ... setting m=simpoints/2 at unate = $unate transition = $transition, loadcap = $loadcap0 >> lant1v0x05_e.error
                end
                if j = 1
                  echo #Error: Failed to find output threshold ... setting m=simpoints/2 at unate = $unate transition = $transition, loadcap = $loadcap1
                  echo #Error: Failed to find output threshold ... setting m=simpoints/2 at unate = $unate transition = $transition, loadcap = $loadcap1 >> lant1v0x05_e.error
                end
                if j = 2
                  echo #Error: Failed to find output threshold ... setting m=simpoints/2 at unate = $unate transition = $transition, loadcap = $loadcap2
                  echo #Error: Failed to find output threshold ... setting m=simpoints/2 at unate = $unate transition = $transition, loadcap = $loadcap2 >> lant1v0x05_e.error
                end
                if j = 3
                  echo #Error: Failed to find output threshold ... setting m=simpoints/2 at unate = $unate transition = $transition, loadcap = $loadcap3
                  echo #Error: Failed to find output threshold ... setting m=simpoints/2 at unate = $unate transition = $transition, loadcap = $loadcap3 >> lant1v0x05_e.error
                end
                if j = 4
                  echo #Error: Failed to find output threshold ... setting m=simpoints/2 at unate = $unate transition = $transition, loadcap = $loadcap4
                  echo #Error: Failed to find output threshold ... setting m=simpoints/2 at unate = $unate transition = $transition, loadcap = $loadcap4 >> lant1v0x05_e.error
                end
                if j = 5
                  echo #Error: Failed to find output threshold ... setting m=simpoints/2 at unate = $unate transition = $transition, loadcap = $loadcap5
                  echo #Error: Failed to find output threshold ... setting m=simpoints/2 at unate = $unate transition = $transition, loadcap = $loadcap5 >> lant1v0x05_e.error
                end
                let m = simpoints / 2
                let int_m = length ( vector ( int_m )) + 1
                label found_m

                let prop_m = int_m-1+($vdd*$outhresh -lower_v)/(upper_v -lower_v)
                let tPROP[10*j+n] = time[int_m-1]+($vdd*$outhresh -lower_v)/(upper_v -lower_v)*(time[int_m]-time[int_m-1])-tP
                let step[10*j+n] = m
*
*               find when the waveform passes the first slope threshold
*
                if next_est = 0
                  let out_slope1 = int_m - 1
                else
                  let out_slope1 = (int_m + next_est)/2
                end
                let index_count = 0
                set incr = 8
                set found_thresh = 0
                while $found_thresh = 0
                  let index_count = index_count + 1
                  if out_slope1 < 1
                    echo #Error: Failed to find first slope threshold at T gt 0
                    echo #Error: Failed to find first slope threshold at T gt 0 >> lant1v0x05_e.error
                    set found_thresh = 1
                    let index_count = tint
                  else
                    if j=0
                      let lower_v = x0z[out_slope1-1]
                      let upper_v = x0z[out_slope1]
                    end
                    if j=1
                      let lower_v = x1z[out_slope1-1]
                      let upper_v = x1z[out_slope1]
                    end
                    if j=2
                      let lower_v = x2z[out_slope1-1]
                      let upper_v = x2z[out_slope1]
                    end
                    if j=3
                      let lower_v = x3z[out_slope1-1]
                      let upper_v = x3z[out_slope1]
                    end
                    if j=4
                      let lower_v = x4z[out_slope1-1]
                      let upper_v = x4z[out_slope1]
                    end
                    if j=5
                      let lower_v = x5z[out_slope1-1]
                      let upper_v = x5z[out_slope1]
                    end
                    if $outfall *(upper_v - $slope1 *$vdd ) <= 0
                      if $outfall *(lower_v - $slope1 *$vdd ) >= 0
                        set found_thresh = 1
                      else
                        if out_slope1 <= $incr
                          set incr = 1
                        end
                        let out_slope1 = out_slope1 - $incr
                      end
                    else
                      set incr = 1
                      let out_slope1 = out_slope1 + $incr
                    end
                    if index_count >= tint
                      set found_thresh = 1
                    end
                  end
                end
                if index_count >= tint
                  if j = 0
                    echo #Error: Failed to find first slope threshold ... using slope at tPROP, unate = $unate transition = $transition, loadcap = $loadcap0
                    echo #Error: Failed to find first slope threshold ... using slope at tPROP, unate = $unate transition = $transition, loadcap = $loadcap0 >> lant1v0x05_e.error
                  end
                  if j = 1
                    echo #Error: Failed to find first slope threshold ... using slope at tPROP, unate = $unate transition = $transition, loadcap = $loadcap1
                    echo #Error: Failed to find first slope threshold ... using slope at tPROP, unate = $unate transition = $transition, loadcap = $loadcap1 >> lant1v0x05_e.error
                  end
                  if j = 2
                    echo #Error: Failed to find first slope threshold ... using slope at tPROP, unate = $unate transition = $transition, loadcap = $loadcap2
                    echo #Error: Failed to find first slope threshold ... using slope at tPROP, unate = $unate transition = $transition, loadcap = $loadcap2 >> lant1v0x05_e.error
                  end
                  if j = 3
                    echo #Error: Failed to find first slope threshold ... using slope at tPROP, unate = $unate transition = $transition, loadcap = $loadcap3
                    echo #Error: Failed to find first slope threshold ... using slope at tPROP, unate = $unate transition = $transition, loadcap = $loadcap3 >> lant1v0x05_e.error
                  end
                  if j = 4
                    echo #Error: Failed to find first slope threshold ... using slope at tPROP, unate = $unate transition = $transition, loadcap = $loadcap4
                    echo #Error: Failed to find first slope threshold ... using slope at tPROP, unate = $unate transition = $transition, loadcap = $loadcap4 >> lant1v0x05_e.error
                  end
                  if j = 5
                    echo #Error: Failed to find first slope threshold ... using slope at tPROP, unate = $unate transition = $transition, loadcap = $loadcap5
                    echo #Error: Failed to find first slope threshold ... using slope at tPROP, unate = $unate transition = $transition, loadcap = $loadcap5 >> lant1v0x05_e.error
                  end
                  let out_slope1 = int_m - 1
                  let next_est = 0
                  let first_time = time[out_slope1-1]
                else
                  let next_est = out_slope1
                  let first_time = time[out_slope1-1]+($slope1 *$vdd -lower_v)/(upper_v-lower_v)*(time[out_slope1]-time[out_slope1-1])
                end

*
*               find when the waveform passes the second slope threshold
*
                if next_est = 0
                  let out_slope1 = int_m
                else
                  let out_slope1 = int_m + (int_m - next_est)/2
                end
                let index_count = 0
                set incr = 8
                set found_thresh = 0
                while $found_thresh = 0
                  let index_count = index_count + 1
                  if out_slope1 > tint
                    echo #Error: Failed to find second slope threshold at T lt $tstop
                    echo #Error: Failed to find second slope threshold at T lt $tstop >> lant1v0x05_e.error
                    set found_thresh = 1
                    let index_count = tint
                  else
                    if j=0
                      let lower_v = x0z[out_slope1]
                      let upper_v = x0z[out_slope1+1]
                    end
                    if j=1
                      let lower_v = x1z[out_slope1]
                      let upper_v = x1z[out_slope1+1]
                    end
                    if j=2
                      let lower_v = x2z[out_slope1]
                      let upper_v = x2z[out_slope1+1]
                    end
                    if j=3
                      let lower_v = x3z[out_slope1]
                      let upper_v = x3z[out_slope1+1]
                    end
                    if j=4
                      let lower_v = x4z[out_slope1]
                      let upper_v = x4z[out_slope1+1]
                    end
                    if j=5
                      let lower_v = x5z[out_slope1]
                      let upper_v = x5z[out_slope1+1]
                    end
                    if $outfall *(lower_v - $slope2 *$vdd ) >= 0
                      if $outfall *(upper_v - $slope2 *$vdd ) <= 0
                        set found_thresh = 1
                      else
                        let out_slope1 = out_slope1 + $incr
                      end
                    else
                      set incr = 1
                      let out_slope1 = out_slope1 - $incr
                    end
                    if index_count >= tint
                      set found_thresh = 1
                    end
                  end
                end
                if index_count >= tint
                  if j = 0
                    echo #Error: Failed to find second slope threshold ... using slope at tPROP, unate = $unate transition = $transition, loadcap = $loadcap0
                    echo #Error: Failed to find second slope threshold ... using slope at tPROP, unate = $unate transition = $transition, loadcap = $loadcap0 >> lant1v0x05_e.error
                  end
                  if j = 1
                    echo #Error: Failed to find second slope threshold ... using slope at tPROP, unate = $unate transition = $transition, loadcap = $loadcap1
                    echo #Error: Failed to find second slope threshold ... using slope at tPROP, unate = $unate transition = $transition, loadcap = $loadcap1 >> lant1v0x05_e.error
                  end
                  if j = 2
                    echo #Error: Failed to find second slope threshold ... using slope at tPROP, unate = $unate transition = $transition, loadcap = $loadcap2
                    echo #Error: Failed to find second slope threshold ... using slope at tPROP, unate = $unate transition = $transition, loadcap = $loadcap2 >> lant1v0x05_e.error
                  end
                  if j = 3
                    echo #Error: Failed to find second slope threshold ... using slope at tPROP, unate = $unate transition = $transition, loadcap = $loadcap3
                    echo #Error: Failed to find second slope threshold ... using slope at tPROP, unate = $unate transition = $transition, loadcap = $loadcap3 >> lant1v0x05_e.error
                  end
                  if j = 4
                    echo #Error: Failed to find second slope threshold ... using slope at tPROP, unate = $unate transition = $transition, loadcap = $loadcap4
                    echo #Error: Failed to find second slope threshold ... using slope at tPROP, unate = $unate transition = $transition, loadcap = $loadcap4 >> lant1v0x05_e.error
                  end
                  if j = 5
                    echo #Error: Failed to find second slope threshold ... using slope at tPROP, unate = $unate transition = $transition, loadcap = $loadcap5
                    echo #Error: Failed to find second slope threshold ... using slope at tPROP, unate = $unate transition = $transition, loadcap = $loadcap5 >> lant1v0x05_e.error
                  end
                  let out_slope1 = int_m
                  let second_time = time[out_slope1+1]
                else
                  let second_time = time[out_slope1]+($slope2 *$vdd -lower_v)/(upper_v-lower_v)*(time[out_slope1]-time[out_slope1-1])
                end

                let out_slope = second_time - first_time
                let tRAMP[10*j+n] = abs ( out_slope / ( $slope1 - $slope2 ))
                let j = j+1
              end *while j <= 5
*
*             Calculate Prop and Ramp delays using all load caps
*             between the second and fourth using the method of least squares
*
              let sumxy = @cx1z[capacitance]*tPROP[10+n]+@cx2z[capacitance]*tPROP[20+n]+@cx3z[capacitance]*tPROP[30+n]+@cx4z[capacitance]*tPROP[40+n]
              let sumy = tPROP[10+n] + tPROP[20+n] + tPROP[30+n] + tPROP[40+n]
              let ramp_z[n] = (4*sumxy-sumx*sumy)/(4*sumx2-sumx^2)
              let prop_z[n]= (sumy*sumx2-sumx*sumxy)/(4*sumx2-sumx^2)
            end *if $power_only = 0
            let icell = strobe*(-vdd0#branch-vss0#branch)
            let iave0 = mean(icell)*($tstop -1000p )/$tstop
            let icell = strobe*(-vdd1#branch-vss1#branch)
            let iave1 = mean(icell)*($tstop -1000p )/$tstop
            let icell = strobe*(-vdd2#branch-vss2#branch)
            let iave2 = mean(icell)*($tstop -1000p )/$tstop
            let icell = strobe*(-vdd3#branch-vss3#branch)
            let iave3 = mean(icell)*($tstop -1000p )/$tstop
            let icell = strobe*(-vdd4#branch-vss4#branch)
            let iave4 = mean(icell)*($tstop -1000p )/$tstop
            if $power_only = 0
              let pvdd0[n] = (iave0*$tstop *$vdd - $loadcap0 *$unitcap *$drive_strength *$vdd *$vdd *($tstop -1000p )/$tstop )/simulation_no + pvdd0[n] *( simulation_no -1)/simulation_no
              let pvdd1[n] = (iave1*$tstop *$vdd - $loadcap1 *$unitcap *$drive_strength *$vdd *$vdd *($tstop -1000p )/$tstop )/simulation_no + pvdd1[n] *( simulation_no -1)/simulation_no
              let pvdd2[n] = (iave2*$tstop *$vdd - $loadcap2 *$unitcap *$drive_strength *$vdd *$vdd *($tstop -1000p )/$tstop )/simulation_no + pvdd2[n] *( simulation_no -1)/simulation_no
              let pvdd3[n] = (iave3*$tstop *$vdd - $loadcap3 *$unitcap *$drive_strength *$vdd *$vdd *($tstop -1000p )/$tstop )/simulation_no + pvdd3[n] *( simulation_no -1)/simulation_no
              let pvdd4[n] = (iave4*$tstop *$vdd - $loadcap4 *$unitcap *$drive_strength *$vdd *$vdd *($tstop -1000p )/$tstop )/simulation_no + pvdd4[n] *( simulation_no -1)/simulation_no
            end
            if $power_only = 1
              if $timing_sense = 0
                let pvdd0[n] = iave0 *$tstop *$vdd /pwr_simulation_no + pvdd0[n] *( pwr_simulation_no -1)/pwr_simulation_no
                let pvdd1[n] = iave1 *$tstop *$vdd /pwr_simulation_no + pvdd1[n] *( pwr_simulation_no -1)/pwr_simulation_no
                let pvdd2[n] = iave2 *$tstop *$vdd /pwr_simulation_no + pvdd2[n] *( pwr_simulation_no -1)/pwr_simulation_no
                let pvdd3[n] = iave3 *$tstop *$vdd /pwr_simulation_no + pvdd3[n] *( pwr_simulation_no -1)/pwr_simulation_no
                let pvdd4[n] = iave4 *$tstop *$vdd /pwr_simulation_no + pvdd4[n] *( pwr_simulation_no -1)/pwr_simulation_no
              else
                let pvdd0[n] = iave0 *$tstop *$vdd /simulation_no + pvdd0[n] *( simulation_no -1)/simulation_no
                let pvdd1[n] = iave1 *$tstop *$vdd /simulation_no + pvdd1[n] *( simulation_no -1)/simulation_no
                let pvdd2[n] = iave2 *$tstop *$vdd /simulation_no + pvdd2[n] *( simulation_no -1)/simulation_no
                let pvdd3[n] = iave3 *$tstop *$vdd /simulation_no + pvdd3[n] *( simulation_no -1)/simulation_no
                let pvdd4[n] = iave4 *$tstop *$vdd /simulation_no + pvdd4[n] *( simulation_no -1)/simulation_no
              end
            end
*
*           Consider current flowing into input pin during input transition time
*
            let trantime = pos(vref#branch)
            if $infall=1
              let in_current = trantime * ( ve_1#branch + ve_2#branch + ve_3#branch )
            else
              let in_current = -trantime * ( ve_1#branch + ve_2#branch + ve_3#branch )
            end
            let ave_cap[n] = mean(in_current) * simtime / $vdd / 3
            let n = n + 1
            destroy all
          end *foreach transition
*
*         Only consider caps from the likeliest input transitions ... 3rd to 7th chosen here
*         in_cap expression changes depending on number of simulations run for this function
*
          let tot_simulation_no = simulation_no + pwr_simulation_no
          let in_cap = in_cap*(tot_simulation_no -1)/(tot_simulation_no ) + ( ave_cap[2]+ave_cap[3]+ave_cap[4]+ave_cap[5]+ave_cap[6] )/5/(tot_simulation_no )
          if $timing_sense < 0
*           For input falling, use transition=130ps for prop-ramp calculation
            if $output_file = 1
*              print col intran tPROP[0,9] tPROP[10,19] tPROP[20,29] tPROP[30,39] tPROP[40,49] tPROP[50,59] > lant1v0x05_e_z_{$other_pin_state}_lh.delay
*              print col intran tRAMP[0,9] tRAMP[10,19] tRAMP[20,29] tRAMP[30,39] tRAMP[40,49] tRAMP[50,59] > lant1v0x05_e_z_{$other_pin_state}_lh.ramp
*              print col intran ave_cap prop_z ramp_z > lant1v0x05_e_z_{$other_pin_state}_lh.vbe
              print col intran ave_cap > lant1v0x05_e_z_{$other_pin_state}_lh.vbe
              if $other_pin_state ne -1
*                let tPlh_z = (tPlh_z + prop_z[4]) / num_pin_states
*                let rup_z = (rup_z + ramp_z[4]) / num_pin_states
*                print tPlh_z rup_z in_cap
                print in_cap
              end
            end
*           For input rising, use transition=130ps for prop-ramp calculation
            if $output_file = 2
              print col intran tPROP[0,9] tPROP[10,19] tPROP[20,29] tPROP[30,39] tPROP[40,49] tPROP[50,59] > lant1v0x05_e_z_{$other_pin_state}_hh.delay
              print col intran tRAMP[0,9] tRAMP[10,19] tRAMP[20,29] tRAMP[30,39] tRAMP[40,49] tRAMP[50,59] > lant1v0x05_e_z_{$other_pin_state}_hh.ramp
              print col intran ave_cap prop_z ramp_z > lant1v0x05_e_z_{$other_pin_state}_hh.vbe
              if $other_pin_state ne -1
                let tPhl_z = (tPhl_z + prop_z[4]) / num_pin_states
                let rdown_z = (rdown_z + ramp_z[4]) / num_pin_states
                print tPhl_z rdown_z in_cap
              end
            end
          end *$timing_sense < 0
          if $timing_sense > 0
*           For input rising, use transition=130ps for prop-ramp calculation
            if $output_file = 1
              print col intran tPROP[0,9] tPROP[10,19] tPROP[20,29] tPROP[30,39] tPROP[40,49] tPROP[50,59] > lant1v0x05_e_z_{$other_pin_state}_hl.delay
              print col intran tRAMP[0,9] tRAMP[10,19] tRAMP[20,29] tRAMP[30,39] tRAMP[40,49] tRAMP[50,59] > lant1v0x05_e_z_{$other_pin_state}_hl.ramp
              print col intran ave_cap prop_z ramp_z > lant1v0x05_e_z_{$other_pin_state}_hl.vbe
              if $other_pin_state ne -1
                let tPhh_z = (tPhh_z + prop_z[4]) / num_pin_states
                let rup_z = (rup_z + ramp_z[4]) / num_pin_states
                print tPhh_z rup_z in_cap
              end
            end
*           For input falling, use transition=130ps for prop-ramp calculation
            if $output_file = 2
*              print col intran tPROP[0,9] tPROP[10,19] tPROP[20,29] tPROP[30,39] tPROP[40,49] tPROP[50,59] > lant1v0x05_e_z_{$other_pin_state}_ll.delay
*              print col intran tRAMP[0,9] tRAMP[10,19] tRAMP[20,29] tRAMP[30,39] tRAMP[40,49] tRAMP[50,59] > lant1v0x05_e_z_{$other_pin_state}_ll.ramp
*              print col intran ave_cap prop_z ramp_z > lant1v0x05_e_z_{$other_pin_state}_ll.vbe
              print col intran ave_cap > lant1v0x05_e_z_{$other_pin_state}_ll.vbe
              if $other_pin_state ne -1
*                let tPll_z = (tPll_z + prop_z[4]) / num_pin_states
*                let rdown_z = (rdown_z + ramp_z[4]) / num_pin_states
*                print tPll_z rdown_z in_cap
                print in_cap
              end
            end
          end *$timing_sense > 0
          if $timing_sense = 0
            if $output_file = 1
              print col intran ave_cap > lant1v0x05_e_z_0_ll.vbe
            end
            if $output_file = 2
              print col intran ave_cap > lant1v0x05_e_z_0_hl.vbe
            end
            if $output_file = 3
              print col intran ave_cap > lant1v0x05_e_z_1_hh.vbe
            end
            if $output_file = 4
              print col intran ave_cap > lant1v0x05_e_z_1_lh.vbe
            end
            if $other_pin_state ne -1
              print in_cap
            end
          end *$timing_sense = 0
* timing_sense output_file       d    z
*     -1            1      0_lh low  high   not possible
*     -1            2      0_hh low   \     same as df
*      1            1      1_hl high  /     same as df
*      1            2      1_ll high low    not possible
*      0            1      0_ll low  low    same as df
*      0            2      0_hl low  low    same as df
*      0            3      1_hh high high   same as df
*      0            4      1_lh high high   same as df

*          plot tPROP[0,9] tPROP[10,19] tPROP[20,29] tPROP[30,39] tPROP[40,49] tPROP[50,59] vs intran
        end *if ( pin_state[ pin_state_index ] < 0 )
        let pin_state_index = pin_state_index + 1
      end *while pin_state_index <= 7
      label ofile
    end *foreach output_file
    print col pvdd0 pvdd1 pvdd2 pvdd3 pvdd4
    print col pvdd0 pvdd1 pvdd2 pvdd3 pvdd4 > lant1v0x05_e_z_{$power_type}.power
  end *foreach timing_sense 1 -1 0
  rusage trantime
.endc
.end
